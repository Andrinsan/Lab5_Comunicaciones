options:
  parameters:
    author: Rivera_Rincon
    generate_options: qt_gui
    id: Lab5_p2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: d1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '25'
  states: {}
- name: d2
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: d3
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: d4
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: fs
  id: variable
  parameters:
    value: samp_rate/100
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: Ancho del pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: d3
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: d2
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: d4
    type: float
  states: {}
- name: options_0_0
  id: options_0
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: options_0_0_1
  id: options_0
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: options_0_0_1_0
  id: options_0
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: options_0_0_3
  id: options_0
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: options_0_1
  id: options_0
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '10240'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', options_0_0, '0']
- [analog_sig_source_x_0_0, '0', options_0_0_1_0, '0']
- [analog_sig_source_x_0_1, '0', options_0_0_3, '0']
- [analog_sig_source_x_0_2, '0', options_0_0_1, '0']
- [blocks_add_xx_0, '0', blocks_delay_1, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_1, '0', options_0_1, '0']
- [options_0_0, '0', blocks_add_xx_0, '0']
- [options_0_0, '0', qtgui_time_sink_x_0, '0']
- [options_0_0_1, '0', blocks_delay_0, '0']
- [options_0_0_1_0, '0', blocks_delay_0_0, '0']
- [options_0_0_3, '0', blocks_delay_0_1, '0']
- [options_0_1, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
